options:
  parameters:
    generate_options: qt_gui
    id: lesson2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Bandwidth
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '200000'
    step: '100'
    stop: '32000000'
    value: '2000000'
  states: {}
- name: Frequency
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '430000000'
    step: '1000'
    stop: '440000000'
    value: '432500000'
  states: {}
- name: RF_Gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '40'
    value: '10'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\GNURADIO\LoRa__cr8_sf07_20.8_02msps.dat
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: Bandwidth
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: Bandwidth
    fc: '432500000'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: Bandwidth
    center_freq0: Frequency
    dc_offs_enb0: '""'
    dev_addr: '"serial=F459AA"'
    dev_args: '""'
    gain0: RF_Gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: Bandwidth
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_throttle_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
