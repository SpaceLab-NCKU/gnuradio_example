options:
  parameters:
    author: gnuradio
    generate_options: qt_gui
    id: lesson7
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Bandwidth
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '200000'
    step: '100'
    stop: '32000000'
    value: '2000000'
  states: {}
- name: D_Factor
  id: variable
  parameters:
    comment: |-
      Based on Sampling Bandwidth is 2M. 
      BW:125K Value 10
      BW:20.8K Value 40
    value: '40'
  states: {}
- name: Frequency
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '430000000'
    step: '1000'
    stop: '440000000'
    value: '432500000'
  states: {}
- name: RF_Gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '40'
    value: '10'
  states: {}
- name: Tab_ID
  id: variable
  parameters:
    value: '"Hello"'
  states: {}
- name: variable_qtgui_check_box_0
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: display@1
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'True'
    ramp: '1'
    threshold: '-50'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_check_box_0
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: Bandwidth
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /media/sf_Share01/IQ Data/LoRa__cr8_sf07_125_02msps.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: display
  id: qtgui_tab_widget
  parameters:
    gui_hint: '[0,0,2,2]'
    label0: Tab 0
    label1: Tab 1
    num_tabs: '2'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '500000'
    decim: D_Factor
    samp_rate: Bandwidth
    taps: '[1]'
    type: ccf
  states: {}
- name: lora_lora_receiver_0
  id: lora_lora_receiver
  parameters:
    bandwidth: '125000'
    center_freq: Frequency
    channel_list: '[433000000]'
    conj: 'False'
    cr: '4'
    crc: 'False'
    decimation: '1'
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'True'
    samp_rate: Bandwidth
    sf: '7'
  states: {}
- name: lora_message_file_sink_0
  id: lora_message_file_sink
  parameters:
    path: /home/gnuradio/Desktop/Lora/file1.txt
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: Bandwidth
    ctrlpanel: 'True'
    fc: Frequency
    fftsize: '1024'
    gui_hint: 'display@0 '
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: Bandwidth/D_Factor
    ctrlpanel: 'True'
    fc: Frequency+500000
    fftsize: '1024'
    gui_hint: 'display@0 '
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: Bandwidth
    fc: Frequency
    fftsize: '1024'
    gui_hint: 'display@0 '
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: Bandwidth/D_Factor
    fc: Frequency+500000
    fftsize: '32'
    gui_hint: 'display@1 '
    int_min: '-80'
    type: complex
    update_time: '0.001'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', lora_lora_receiver_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [lora_lora_receiver_0, frames, lora_message_file_sink_0, in]

metadata:
  file_format: 1
